Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T08:24:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 08:24:52 2018 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{9F89238A-1565-41A5-8EF3-F304D754B5A4}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 08:24:50 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 08:24:50 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 08:24:50 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: .03 not stackable, CONV_Vitra_DmstcChrs_.03:.03 not stackable:310808
In: Level 1
Material: 01 basic dark, Glide white, Basic dark
Pset_ManufacturerTypeInformation - ModelReference: 44042600; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.91445 m2; Volume: 0.157605 m3
Materials and Finishes - ChairMainMaterial: 01 basic dark
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_.03: .03 not stackable; Family and Type: CONV_Vitra_DmstcChrs_.03: .03 not stackable; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_.03: .03 not stackable; Type Id: CONV_Vitra_DmstcChrs_.03: .03 not stackable; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_.03; ConvergoRefNr: 0089-1812-0054-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The extraordinary comfort of the unobtrusive .03 chair is first revealed upon use: the seat shell, which is made of resilient integral skin polyurethane foam, adapts to the user's body and flexes slightly when the sitter leans back, aided by leaf springs embedded in the backrest.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 19/12/2018
Identity Data(Type) - Collection: .03; Cost: 0; Description: The extraordinary comfort of the unobtrusive .03 chair is first revealed upon use: the seat shell, which is made of resilient integral skin polyurethane foam, adapts to the user's body and flexes slightly when the sitter leans back, aided by leaf springs embedded in the backrest.; Designer: Maarten Van Severen; Manufacturer: Vitra; Model: .03 not stackable; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/191044/storage/master/download/Factsheet%20.03-EN.pdf; Type Name: .03 not stackable; URL: https://www.vitra.com/en-un/living/product/details/03
Materials and Finishes(Type) - ChairSecondaryMaterial: Basic dark; ChairTertiaryMaterial: Glide white
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_.03; Features: Flexible backrest with integrated leaf springs. Not stackable. Fitted with plastic glides for carpet or felt glides for hard floors.; Finish: Seat shell: integral skin polyurethane foam. Shell with upholstered effect, self-supporting on a tubular steel frame. Flexible backrest with integrated leaf springs. Base/stackability: back legs in tubular steel, front legs in aluminium profile, powdercoated or chrome-plated. Fitted with plastic glides forcarpet or felt glides for hard floors.; Grade: n/a; Material: Polyurethane, steel, aluminium & felt; ModelNumber: n/a; ModelReference: 44042600; Name: DmstcChrs_.03; ReplacementCost: n/a; Shape: Sculptured; Size: 380x790x525 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
